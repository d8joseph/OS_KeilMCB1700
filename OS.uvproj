# Keil uVision project OS.uvproj, settings and files
target OS (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: OS
  c flags: Optim=1
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./src/: HAL.c main_svc.c printf.c system_LPC17xx.c uart_irq.c uart_polling.c timer.c
  group Kernel Code
    ./src/: min_heap.c k_memory.c k_process.c k_rtx_init.c null_process.c queue.c k_messaging.c CRT.c i_timer_proc.c i_uart_proc.c KCD.c
  group User Code
    ./src/: usr_proc.c stress_test.c set_priority.c wall_clock.c
